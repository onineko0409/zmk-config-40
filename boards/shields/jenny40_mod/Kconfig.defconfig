## boards/shields/jenny40_mod/Kconfig.defconfig
```kconfig
if SHIELD_JENNY40_MOD

config ZMK_KEYBOARD_NAME
    default "Jenny40 Mod"

endif # SHIELD_JENNY40_MOD
```
